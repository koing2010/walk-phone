# IAR project Backup (3) of ucos_stm8s.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105K4 STM8S105K4
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x300
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S207
  ICCSTM8.CCDiagSuppress: pa089
  ICCSTM8.CCIncludePath2: ..\..\ucos_ii\; ..\..\ucos_ii\iarstm8; ..\src; ..\fwlib\inc
  ICCSTM8.IccLang: 0
  ASTM8.AsmIncludePath: ..\..\ucos_ii\iarstm8
  OBJCOPY.OOCOutputFile: ucos_stm8s.srec
  ILINK.IlinkOutputFile: yyy.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group UCOS_II
    ../../ucos_II/: OS_CORE.C OS_FLAG.C OS_MBOX.C OS_MEM.C OS_MUTEX.C OS_Q.C OS_SEM.C OS_TASK.C OS_TIME.C
  group UCOS_II/iarstm8
    ../../ucos_II/iarstm8/: os_cpu_a.s os_cpu_c.c
  group user
    ../src/: at1846s.c at1846s.h init_peripher.c interrupt.c main.c periph_ticks.s rda1846s.c
